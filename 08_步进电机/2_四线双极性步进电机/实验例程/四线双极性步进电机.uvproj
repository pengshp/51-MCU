# Keil uVision project 四线双极性步进电机.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC90C58RD+ STC
  cpu: IRAM(0-0xFF) XRAM(0-0x3FF) IROM(0-0x7FFF) CLOCK(45000000) MODP2
  output: 四线双极性步进电机 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: main.c
