# Keil uVision project UART_resevice.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC90C58RD+ STC
  cpu: IRAM(0-0xFF) XRAM(0-0x3FF) IROM(0-0x7FFF) CLOCK(45000000) MODP2
  output: UART_resevice +hex
  c flags: Optimize=9 SizeSpeed=1
  group Source Group 1
    ./: main.c
